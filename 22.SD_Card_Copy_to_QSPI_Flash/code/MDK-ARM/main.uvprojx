# Keil uVision project main.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Core\Src\hardware\spi_flash;..\Core\Src\hardware\test_api;..\Core\Src\hardware\lcd;..\Core\Src\hardware\aux_data;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\EMWIN\STemWinLibrary532\Config;..\EMWIN\STemWinLibrary532\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c quadspi.c sdmmc.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Hardware
    ../Core/Src/hardware/lcd/: font.h bsp_bmp.c lcd_spi2_drv.c
    ../Core/Src/hardware/test_api/: test.c
    ../Core/Src/hardware/aux_data/: aux_data.c
    ../Core/Src/hardware/spi_flash/: bsp_w25q64.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group EMWIN_Config
    ../EMWIN/STemWinLibrary532/OS/: GUI_X.c
    ../EMWIN/STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c
  group EMWIN_LIB
    ../EMWIN/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group EMWIN_APP
    ../EMWIN/STemWinLibrary532/Software/: FramewinDLG.c
software components: CMSIS:CORE 4.3.0
