# Keil uVision project main.uvprojx, settings and files
target main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,OS_SUPPORT
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\..\arch\arm\arm-v7m\common\include;..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\kernel\core\include;..\..\kernel\pm\include;..\..\kernel\hal\include;..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\Core\Src\logic;..\Core\Src\hardware\Key;..\Core\Src\hardware\LCD-SPI;..\Core\Src\hardware\filesystem;..\Core\Src\EMWIN\STemWinLibrary532\inc;..\Core\Src\EMWIN\STemWinLibrary532\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c rtc.c sdmmc.c spi.c tim.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Hardware
    ../Core/Src/hardware/Key/: key.c
    ../Core/Src/hardware/filesystem/: filesystem.c
    ../Core/Src/hardware/LCD-SPI/: lcd_spi2_drv.c
  group app_logic
    ../Core/Src/logic/: app_init.c bsp_bmp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group tos/arch
    ../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ../../arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/config
    ../../TOS_CONFIG/: tos_config.h
  group tos/kernel
    ../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis_os
    ../../osal/cmsis_os/: cmsis_os.c
  group emwin_config
    ../Core/Src/EMWIN/STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../Core/Src/EMWIN/STemWinLibrary532/OS/: GUI_X_TOS.c
  group emwin_lib
    ../Core/Src/EMWIN/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
